# Repository seblovett/RGB_Clock

File README.md:

RGB_Clock
=========

A LED Clock

A contained PCB clock, with 60 RGB LEDs to display the time. 

Includes a noise sensor, LDR to adjust the brightness.

## KiCad design Schematics/Display_Sub.kicad_pcb

Board: 2 copper layers, 17.0 x 24.0 mm, 20 parts (10 on the bottom side), 24 nets.

Parts:
C1, C101: C; C_0603
P1, P2, P3, P4, P5: CONN_01X04; JST-BM-04B-SRSS-TB
P6: CONN_01X06; JST-BM-06B-SRSS-TB
R1, R2, R3, R4, R5, R6, R7, R8: 0R; R_0603
R9, R10, R11: 10k; R_0603
U1: PCA9685; TSSOP-28_4.4x9.7mm_Pitch0.65mm

Connections:
/ID0: R1.2, R5.1, U1.1
/ID1: R2.2, R6.1, U1.2
/ID2: R3.2, R7.1, U1.3
/ID3: R4.2, R8.1, U1.4
/SCL: P6.3, R10.2, U1.26
/SDA: P6.2, R11.2, U1.27
/~OE: P6.5, R9.2, U1.23
GND: C1.2, C101.2, P6.4, P6.6, R5.2, R6.2, R7.2, R8.2, U1.14, U1.25
unnamed: P1.2, U1.6
unnamed: P1.3, U1.7
unnamed: P1.4, U1.8
unnamed: P2.2, U1.9
unnamed: P2.3, U1.10
unnamed: P2.4, U1.11
unnamed: P3.2, U1.12
unnamed: P3.3, U1.13
unnamed: P3.4, U1.15
unnamed: P4.2, U1.16
unnamed: P4.3, U1.17
unnamed: P4.4, U1.18
unnamed: P5.2, U1.19
unnamed: P5.3, U1.20
unnamed: P5.4, U1.21
VPP: C1.1, C101.1, P1.1, P2.1, P3.1, P4.1, P5.1, P6.1, R1.1, R2.1, R3.1, R4.1, R9.1, R10.1, R11.1, U1.5, U1.24, U1.28

## KiCad design Schematics/Root.kicad_pcb

Parts:
CON2: BARREL_JACK; JACK_ALIM; Part PRT-10811
P1, P2, P3, P4, P5, P6, P7, P8, P9, P10, P11, P12: CONN_01X06

Connections:
/Microcontroller/SCL: P1.3, P2.3, P3.3, P4.3, P5.3, P6.3, P7.3, P8.3, P9.3, P10.3, P11.3, P12.3; also elsewhere on the board
/Microcontroller/SDA: P1.2, P2.2, P3.2, P4.2, P5.2, P6.2, P7.2, P8.2, P9.2, P10.2, P11.2, P12.2; also elsewhere on the board
/Power Supply/Vin: CON2.1; also elsewhere on the board
/~OE1: P1.5; also elsewhere on the board
/~OE2: P2.5; also elsewhere on the board
/~OE3: P3.5; also elsewhere on the board
/~OE4: P4.5; also elsewhere on the board
/~OE5: P5.5; also elsewhere on the board
/~OE6: P6.5; also elsewhere on the board
/~OE7: P7.5; also elsewhere on the board
/~OE8: P8.5; also elsewhere on the board
/~OE9: P9.5; also elsewhere on the board
/~OE10: P10.5; also elsewhere on the board
/~OE11: P11.5; also elsewhere on the board
/~OE12: P12.5; also elsewhere on the board
GND: CON2.2, CON2.3, P1.4, P1.6, P2.4, P2.6, P3.4, P3.6, P4.4, P4.6, P5.4, P5.6, P6.4, P6.6, P7.4, P7.6, P8.4, P8.6, P9.4, P9.6, P10.4, P10.6, P11.4, P11.6, P12.4, P12.6; also elsewhere on the board
VPP: P1.1, P2.1, P3.1, P4.1, P5.1, P6.1, P7.1, P8.1, P9.1, P10.1, P11.1, P12.1; also elsewhere on the board

Parts:
BT1: 3V; BU2032SM-HD-GTR-ND; Part BU2032SM-HD-GTR-ND
C10, C12: 33pF; C_0603
C11, C13: 22pF; C_0603
C14: 1u; C_0603
C15, C16, C17, C18, C19: 100n; C_0603
CON1: USB-MICRO-B; USB_Mini-B
IC1: ATXMEGA256A3BU-A; TQFP-64_14x14mm_Pitch0.8mm; Part ATXMEGA256A3BU-A
J1: AVR_JTAG_Header; FTSH-105-01-L-DV-K-A-P; Part FTSH-105-01-L-DV-K-A-P
JP1, JP2, JP3: JUMPER; R_0603
P13, P14: CONN_01X02; Pin_Header_Straight_1x02
R15: 100R; R_0603
R17, R18: 47k; R_0603
R100: 100k; R_0603
SW1, SW2: SW_PUSH; SW; Part MC32882
X1: 16MHz; crystal_FA238-TSX3225; Part ABM8-16.000MHZ-B2-T
X2: 32.768KhZ; SMD_Osc; Part ABS06-32.768KHZ-1-T

Connections:
/Microcontroller/AVR_RXD: IC1.22 (MISO/RXD1/~OC0DLS~/PC6), P14.1
/Microcontroller/AVR_TXD: IC1.23 (EVOUT/CLKP/SCK/TXD1/OC0DHS/PC7), P14.2
/Microcontroller/JUMPER: IC1.38 (PE2/OC0C/RXD0), JP1.1, R100.2
/Microcontroller/SCL: IC1.17 (SCL/XCK0/OC0AHS/OC0B/PC1), R18.2; also elsewhere on the board
/Microcontroller/SDA: IC1.16 (SDA/~OC0ALS~/OC0A/PC0), R17.2; also elsewhere on the board
/Microcontroller/SW1: IC1.18 (SDAOUT/RXD0/~OC0BLS~/OC0C/PC2), SW1.1
/Microcontroller/SW2: IC1.1 (AC3/ADC11/ADC3/PA3), JP3.1
/Microcontroller/TCK: IC1.12 (TCK/AC1OUT/AC6/ADC6/ADC14/PB6), J1.1
/Microcontroller/TDI: IC1.11 (TDI/AC5/ADC5/ADC13/PB5), J1.9
/Microcontroller/TDO: IC1.13 (TDO/AC0OUT/AC7/ADC7/ADC15/PB7), J1.3
/Microcontroller/TMS: IC1.10 (TMS/AC4/ADC4/ADC12/PB4), J1.5
/Microcontroller/TOSC1: C11.1, IC1.43 (TOSC1), X2.1
/Microcontroller/TOSC2: C13.1, IC1.42 (TOSC2), X2.2
/Microcontroller/USB_D+: CON1.3 (D+), IC1.33 (EVOUT/CLKP/SCK/TXD1/D+/PD7)
/Microcontroller/USB_D-: CON1.2 (D-), IC1.32 (MISO/RXD1/D-/PD6)
/Microcontroller/~RESET: IC1.57 (~RESET~/PDI_CLK), J1.6, JP2.1
/~OE1: IC1.2 (AC4/ADC12/ADC4/PA4); also elsewhere on the board
/~OE2: IC1.64 (AC2/ADC10/ADC2/PA2); also elsewhere on the board
/~OE3: IC1.63 (AC1/ADC9/ADC1/PA1); also elsewhere on the board
/~OE4: IC1.62 (AREF/AC0/ADC8/ADC0/PA0); also elsewhere on the board
/~OE5: IC1.55 (PF7); also elsewhere on the board
/~OE6: IC1.39 (PE3/OC0D/TXD0); also elsewhere on the board
/~OE7: IC1.31 (MOSI/XCK1/OC1B/PD5); also elsewhere on the board
/~OE8: IC1.30 (~SS~/OC1A/PD4); also elsewhere on the board
/~OE9: IC1.29 (TXD0/OC0D/PD3); also elsewhere on the board
/~OE10: IC1.5 (AC0OUT/AC7/ADC15/ADC7/PA7); also elsewhere on the board
/~OE11: IC1.4 (AC1OUT/AC6/ADC14/ADC6/PA6); also elsewhere on the board
/~OE12: IC1.3 (AC5/ADC13/ADC5/PA5); also elsewhere on the board
GND: BT1.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, CON1.4 (ID), CON1.5 (GND), CON1.6 (SHELL1), CON1.7 (SHELL2), CON1.8 (SHELL3), CON1.9 (SHELL4), IC1.14 (GND), IC1.24 (GND), IC1.34 (GND), IC1.44 (GND), IC1.52 (GND), IC1.60 (GND), J1.2, J1.10, JP1.2, P13.2, SW1.2, SW2.2, X1.3 (case), X2.3 (case); also elsewhere on the board
unnamed: BT1.1, R15.2
unnamed: C10.1, IC1.58 (PR0/XTAL2), X1.1
unnamed: C12.1, IC1.59 (PR1/XTAL1), X1.2
unnamed: IC1.51 (VBAT), R15.1
unnamed: JP2.2, JP3.2, SW2.1
VPP: C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, IC1.15 (VCC), IC1.25 (VCC), IC1.35 (VCC), IC1.45 (VCC), IC1.53 (VCC), IC1.61 (AVCC), J1.4, P13.1, R17.1, R18.1, R100.1; also elsewhere on the board

Notes on the sheet:
Load capacitance of OSC pins = 3pF

Parts:
C33: 10u; C_0603
C34: 10n; C_0402
C35: 1u; C_0402
C36: 100n; C_0402
C37: 10p; C_0402
C38: 47n; C_0603
C39: 47n; C_0603; Part Murata
D1: LED; LED-1206
L1: 3.2u; SD43; Part SD43-332ML
R31: 220R; R_0603
R32: 41.2k; R_0402
R33: 2.4M; R_0402
R34: 1M; R_0402
U13: LT8612; 28QFN

Connections:
/Power Supply/BST: C36.2, U13.20
/Power Supply/FB: C37.2, R33.2, R34.1, U13.24
/Power Supply/IntVcc: C35.1, U13.21
/Power Supply/PG: R31.2, U13.23
/Power Supply/Rt: R32.1, U13.3
/Power Supply/SS: C34.1, U13.2
/Power Supply/SW: C36.1, L1.1, U13.15, U13.16, U13.17, U13.18, U13.19
/Power Supply/Vin: C33.1, U13.4, U13.5, U13.6, U13.7; also elsewhere on the board
GND: C33.2, C34.2, C35.2, C38.2, C39.2, R32.2, R34.2, U13.1, U13.8, U13.9, U13.10, U13.11, U13.12, U13.13, U13.14, U13.25, U13.26, U13.27, U13.28, U13.29; also elsewhere on the board
unnamed: D1.2 (K), R31.1
VPP: C37.1, C38.1, C39.1, D1.1 (A), L1.2, R33.1, U13.22; also elsewhere on the board

Board: 2 copper layers, 50.0 x 50.0 mm, 54 parts (14 on the bottom side), 44 nets.

## KiCad design Schematics/Clock_10cm.kicad_pcb

Board: 2 copper layers, 100.0 x 100.0 mm, 139 parts (1 on the bottom side), 230 nets.

Parts:
BT1: 3V; BU2032SM-HD-GTR-ND
C10, C11, C12, C13, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C32: C; C_0603
C14: 1u; C_0603
C15, C16, C17, C18, C19: 100n; C_0603
C33: 10u; C_0603
C34: 10n; C_0402
C35: 1u; C_0402
C36: 100n; C_0402
C37: 10p; C_0402
C38, C39: 47n; C_0603
CON1: USB-MICRO-B; USB_Mini-B
CON2: BARREL_JACK; JACK_ALIM
D1: LED; LED-1206
IC1: ATXMEGA256A3BU-A; TQFP-64_14x14mm_Pitch0.8mm
J1: AVR_JTAG_Header; FTSH-105-01-L-DV-K-A-P
JP1, JP2, JP3: JUMPER; R_0603
L1: 3.2u; SD43
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12, LED13, LED14, LED15, LED16, LED17, LED18, LED19, LED20, LED21, LED22, LED23, LED24, LED25, LED26, LED27, LED28, LED29, LED30, LED31, LED32, LED33, LED34, LED35, LED36, LED37, LED38, LED39, LED40, LED41, LED42, LED43, LED44, LED45, LED46, LED47, LED48, LED49, LED50, LED51, LED52, LED53, LED54, LED55, LED56, LED57, LED58, LED59, LED60: LED_RGB; rgbled1
P1: CONN_02X08; Socket_Strip_Straight_2x08
R15: 100R; R_0603
R17, R18: 47k; R_0603
R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30: 10k; R_0603
R31: 220R; R_0603
R32: 41.2k; R_0402
R33: 2.4M; R_0402
R34: 1M; R_0402
R100: 100k; R_0603
SW1, SW2, SW3, SW4: SW_PUSH; SW
U1, U2, U3, U4, U5, U6, U7, U8, U9, U10, U11, U12: PCA9685; TSSOP-28_4.4x9.7mm_Pitch0.65mm
U13: LT8612; 28QFN
X1: 16MHz; crystal_FA238-TSX3225
X2: 32.768KhZ; SMD_Osc

Connections:
/Display/Display Sub block 1/~OE: IC1.26, R23.2, U1.23
/Display/Display Sub block 2/~OE: IC1.27, R25.2, U2.23
/Display/Display Sub block 3/~OE: IC1.28, R19.2, U3.23
/Display/Display Sub block 4/~OE: IC1.29, R21.2, U4.23
/Display/Display Sub block 5/~OE: IC1.30, R27.2, U5.23
/Display/Display Sub block 6/~OE: IC1.31, R29.2, U6.23
/Display/Display Sub block 7/~OE: IC1.48, R24.2, U7.23
/Display/Display Sub block 8/~OE: IC1.49, R26.2, U8.23
/Display/Display Sub block 9/~OE: IC1.50, R20.2, U9.23
/Display/Display Sub block 10/~OE: IC1.62, R22.2, U10.23
/Display/Display Sub block 11/~OE: IC1.63, R28.2, U11.23
/Display/Display Sub block 12/~OE: IC1.64, R30.2, U12.23
/Display/SCL: IC1.17, P1.3, R18.2, U1.26, U2.26, U3.26, U4.26, U5.26, U6.26, U7.26, U8.26, U9.26, U10.26, U11.26, U12.26
/Display/SDA: IC1.16, P1.1, R17.2, U1.27, U2.27, U3.27, U4.27, U5.27, U6.27, U7.27, U8.27, U9.27, U10.27, U11.27, U12.27
/Microcontroller/JUMPER: IC1.41, JP1.1, R100.2
/Microcontroller/MISO: IC1.22, P1.7
/Microcontroller/MOSI: IC1.21, P1.9
/Microcontroller/RX: IC1.18, P1.15
/Microcontroller/SCK: IC1.23, P1.5
/Microcontroller/SW1: IC1.6, SW1.1
/Microcontroller/SW2: IC1.7, JP3.1
/Microcontroller/SW3: IC1.8, SW3.1
/Microcontroller/SW4: IC1.9, SW4.1
/Microcontroller/TCK: IC1.12, J1.1
/Microcontroller/TDI: IC1.11, J1.9
/Microcontroller/TDO: IC1.13, J1.3
/Microcontroller/TMS: IC1.10, J1.5
/Microcontroller/TOSC1: C11.1, IC1.43, X2.1
/Microcontroller/TOSC2: C13.1, IC1.42, X2.2
/Microcontroller/TX: IC1.19, P1.13
/Microcontroller/USB_D+: CON1.3, IC1.33
/Microcontroller/USB_D-: CON1.2, IC1.32
/Microcontroller/~CS: IC1.20, P1.11
/Microcontroller/~RESET: IC1.57, J1.6, JP2.1
/Power Supply/BST: C36.2, U13.20
/Power Supply/FB: C37.2, R33.2, R34.1, U13.24
/Power Supply/IntVcc: C35.1, U13.21
/Power Supply/PG: R31.2, U13.23
/Power Supply/Rt: R32.1, U13.3
/Power Supply/SS: C34.1, U13.2
/Power Supply/SW: C36.1, L1.1, U13.15, U13.16, U13.17, U13.18, U13.19
/Power Supply/Vin: C33.1, CON2.1, U13.4, U13.5, U13.6, U13.7
GND: BT1.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C38.2, C39.2, CON1.4, CON1.5, CON1.6, CON1.7, CON1.8, CON1.9, CON2.2, CON2.3, IC1.14, IC1.24, IC1.34, IC1.44, IC1.52, IC1.60, J1.2, J1.10, JP1.2, P1.2, P1.4, P1.6, P1.8, P1.10, P1.12, P1.14, P1.16, R32.2, R34.2, SW1.2, SW2.2, SW3.2, SW4.2, U1.2, U1.3, U1.4, U1.14, U1.25, U2.1, U2.3, U2.4, U2.14, U2.25, U3.3, U3.4, U3.14, U3.25, U4.1, U4.2, U4.4, U4.14, U4.25, U5.2, U5.4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
unnamed: BT1.1, R15.2
unnamed: C10.1, IC1.58, X1.1
unnamed: C12.1, IC1.59, X1.2
unnamed: D1.2, R31.1
unnamed: IC1.51, R15.1
unnamed: JP2.2, JP3.2, SW2.1
unnamed: LED1.BC, U1.8
unnamed: LED1.GC, U1.7
unnamed: LED1.RC, U1.6
unnamed: LED2.BC, U1.11
unnamed: LED2.GC, U1.10
unnamed: LED2.RC, U1.9
unnamed: LED3.BC, U1.15
unnamed: LED3.GC, U1.13
unnamed: LED3.RC, U1.12
unnamed: LED4.BC, U1.18
unnamed: LED4.GC, U1.17
unnamed: LED4.RC, U1.16
unnamed: LED5.BC, U1.21
unnamed: LED5.GC, U1.20
unnamed: LED5.RC, U1.19
unnamed: LED6.BC, U2.8
unnamed: LED6.GC, U2.7
unnamed: LED6.RC, U2.6
unnamed: LED7.BC, U2.11
unnamed: LED7.GC, U2.10
unnamed: LED7.RC, U2.9
unnamed: LED8.BC, U2.15
unnamed: LED8.GC, U2.13
unnamed: LED8.RC, U2.12
unnamed: LED9.BC, U2.18
unnamed: LED9.GC, U2.17
unnamed: LED9.RC, U2.16
unnamed: LED10.BC, U2.21
unnamed: LED10.GC, U2.20
unnamed: LED10.RC, U2.19
unnamed: LED11.BC, U3.8
unnamed: LED11.GC, U3.7
unnamed: LED11.RC, U3.6
unnamed: LED12.BC, U3.11
unnamed: LED12.GC, U3.10
unnamed: LED12.RC, U3.9
unnamed: LED13.BC, U3.15
unnamed: LED13.GC, U3.13
unnamed: LED13.RC, U3.12
unnamed: LED14.BC, U3.18
unnamed: LED14.GC, U3.17
unnamed: LED14.RC, U3.16
unnamed: LED15.BC, U3.21
unnamed: LED15.GC, U3.20
unnamed: LED15.RC, U3.19
unnamed: LED16.BC, U4.8
unnamed: LED16.GC, U4.7
unnamed: LED16.RC, U4.6
unnamed: LED17.BC, U4.11
unnamed: LED17.GC, U4.10
unnamed: LED17.RC, U4.9
unnamed: LED18.BC, U4.15
unnamed: LED18.GC, U4.13
unnamed: LED18.RC, U4.12
unnamed: LED19.BC, U4.18
unnamed: LED19.GC, U4.17
unnamed: LED19.RC, U4.16
unnamed: LED20.BC, U4.21
unnamed: LED20.GC, U4.20
unnamed: LED20.RC, U4.19
unnamed: LED21.BC, U5.8
unnamed: LED21.GC, U5.7
unnamed: LED21.RC, U5.6
unnamed: LED22.BC, U5.11
unnamed: LED22.GC, U5.10
unnamed: LED22.RC, U5.9
unnamed: LED23.BC, U5.15
unnamed: LED23.GC, U5.13
unnamed: LED23.RC, U5.12
unnamed: LED24.BC, U5.18
unnamed: LED24.GC, U5.17
unnamed: LED24.RC, U5.16
unnamed: LED25.BC, U5.21
unnamed: LED25.GC, U5.20
unnamed: LED25.RC, U5.19
unnamed: LED26.BC, U6.8
unnamed: LED26.GC, U6.7
unnamed: LED26.RC, U6.6
unnamed: LED27.BC, U6.11
unnamed: LED27.GC, U6.10
unnamed: LED27.RC, U6.9
unnamed: LED28.BC, U6.15
unnamed: LED28.GC, U6.13
unnamed: LED28.RC, U6.12
unnamed: LED29.BC, U6.18
unnamed: LED29.GC, U6.17
unnamed: LED29.RC, U6.16
unnamed: LED30.BC, U6.21
unnamed: LED30.GC, U6.20
unnamed: LED30.RC, U6.19
unnamed: LED31.BC, U7.8
unnamed: LED31.GC, U7.7
unnamed: LED31.RC, U7.6
unnamed: LED32.BC, U7.11
unnamed: LED32.GC, U7.10
unnamed: LED32.RC, U7.9
unnamed: LED33.BC, U7.15
unnamed: LED33.GC, U7.13
unnamed: LED33.RC, U7.12
unnamed: LED34.BC, U7.18
unnamed: LED34.GC, U7.17
unnamed: LED34.RC, U7.16
unnamed: LED35.BC, U7.21
unnamed: LED35.GC, U7.20
unnamed: LED35.RC, U7.19
unnamed: LED36.BC, U8.8
unnamed: LED36.GC, U8.7
unnamed: LED36.RC, U8.6
unnamed: LED37.BC, U8.11
unnamed: LED37.GC, U8.10
unnamed: LED37.RC, U8.9
unnamed: LED38.BC, U8.15
unnamed: LED38.GC, U8.13
unnamed: LED38.RC, U8.12
unnamed: LED39.BC, U8.18
unnamed: LED39.GC, U8.17
unnamed: LED39.RC, U8.16
unnamed: LED40.BC, U8.21
unnamed: LED40.GC, U8.20
unnamed: LED40.RC, U8.19
unnamed: LED41.BC, U9.8
unnamed: LED41.GC, U9.7
unnamed: LED41.RC, U9.6
unnamed: LED42.BC, U9.11
unnamed: LED42.GC, U9.10
unnamed: LED42.RC, U9.9
unnamed: LED43.BC, U9.15
unnamed: LED43.GC, U9.13
unnamed: LED43.RC, U9.12
unnamed: LED44.BC, U9.18
unnamed: LED44.GC, U9.17
unnamed: LED44.RC, U9.16
unnamed: LED45.BC, U9.21
unnamed: LED45.GC, U9.20
unnamed: LED45.RC, U9.19
unnamed: LED46.BC, U10.8
unnamed: LED46.GC, U10.7
unnamed: LED46.RC, U10.6
unnamed: LED47.BC, U10.11
unnamed: LED47.GC, U10.10
unnamed: LED47.RC, U10.9
unnamed: LED48.BC, U10.15
unnamed: LED48.GC, U10.13
unnamed: LED48.RC, U10.12
unnamed: LED49.BC, U10.18
unnamed: LED49.GC, U10.17
unnamed: LED49.RC, U10.16
unnamed: LED50.BC, U10.21
unnamed: LED50.GC, U10.20
unnamed: LED50.RC, U10.19
unnamed: LED51.BC, U11.8
unnamed: LED51.GC, U11.7
unnamed: LED51.RC, U11.6
unnamed: LED52.BC, U11.11
unnamed: LED52.GC, U11.10
unnamed: LED52.RC, U11.9
unnamed: LED53.BC, U11.15
unnamed: LED53.GC, U11.13
unnamed: LED53.RC, U11.12
unnamed: LED54.BC, U11.18
unnamed: LED54.GC, U11.17
unnamed: LED54.RC, U11.16
unnamed: LED55.BC, U11.21
unnamed: LED55.GC, U11.20
unnamed: LED55.RC, U11.19
unnamed: LED56.BC, U12.8
unnamed: LED56.GC, U12.7
unnamed: LED56.RC, U12.6
unnamed: LED57.BC, U12.11
unnamed: LED57.GC, U12.10
unnamed: LED57.RC, U12.9
unnamed: LED58.BC, U12.15
unnamed: LED58.GC, U12.13
unnamed: LED58.RC, U12.12
unnamed: LED59.BC, U12.18
unnamed: LED59.GC, U12.17
unnamed: LED59.RC, U12.16
unnamed: LED60.BC, U12.21
unnamed: LED60.GC, U12.20
unnamed: LED60.RC, U12.19
VPP: C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C37.1, C38.1, C39.1, D1.1, IC1.15, IC1.25, IC1.35, IC1.45, IC1.53, IC1.61, J1.4, L1.2, LED1.BA, LED1.GA, LED1.RA, LED2.BA, LED2.GA, LED2.RA, LED3.BA, LED3.GA, LED3.RA, LED4.BA, LED4.GA, LED4.RA, LED5.BA, LED5.GA, LED5.RA, LED6.BA, LED6.GA, LED6.RA, LED7.BA, LED7.GA, LED7.RA, LED8.BA, LED8.GA, LED8.RA, LED9.BA, LED9.GA, LED9.RA, LED10.BA, LED10.GA, LED10.RA, LED11.BA, LED11.GA, LED11.RA, LED12.BA, LED12.GA, LED12.RA, LED13.BA, LED13.GA, LED13.RA, LED14.BA, LED14.GA, LED14.RA, LED15.BA, LED15.GA, LED15.RA, LED16.BA, LED16.GA, LED16.RA, LED17.BA, LED17.GA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

## Commit log

2014-12-29 Added datasheets
2014-12-29 Added base design. Much to do!
2014-12-29 Ignore shtuff
2014-12-29 Some useful tings to generate long commands for placing LEDs in the right place
2014-12-30 connected all PWM and LEDs.
2014-12-30 Probably joined with last commit..
2015-01-10 Redone schematics in KiCAD.
    Need to sort out ref des' for LEDs and PWM drivers and then can begin some layout!
2015-01-10 LEDs are placed!
    Worked out how to script KiCAD to do it too. Winner winner, time for a chicken dinner
2015-01-14 Latest schematics and pcb.
2015-01-14 Removed old EAGLE stuff.
2015-01-14 Added all CAD files
2015-01-14 Added libraries
2015-01-14 Updated script. Moves the PWM ICs also
2015-01-14 Added schematic lib
2015-01-14 Removed back up file
2015-01-27 Updated schematics
2015-01-27 Removed RF. Placed all LED drivers and passives and begun routing
2015-01-27 Corrected part
2015-01-28 Added power in connector in schematics. #3
2015-01-28 Added some switches for interface #7
2015-01-28 Changed to TSSOP package
2015-01-28 Changed lots
    Finalised the Inductor. Closes #5
    Changed USB Connector. Closes #4
    Added four switches for a simple interface. Closes #7
    Added a power jack. Closes #3
    Found RTC Oscillator. Closes #1.
    Added part numbers to all major components. Closes #2
2015-01-29 Ammended a net. Done a lot of routing
2015-01-30 Done lots of routing. Mostly done.
    Rearranged some connections to make routing easier.
    Need to check unconnected nets.
2015-02-01 Main GND plane added.
    Need to add island plane for SMPS
2015-02-01 Sorted SMPS ground plane
2015-02-01 Sorted silkscreen out. Added a select to change function of one of the switches to between a reset or a general purpose
2015-02-01 Added some libs
2015-02-01 Added the datasheet for the ATXMega used
2015-02-01 Added SMPS related things
2015-02-01 Updated git ignore
2015-02-01 Added clock face to silkscreen
2015-02-09 Completed layout of 10cm board. Fixes #8
2015-02-09 added some more datasheets
2015-02-09 Added BoM with costings.
    Also added schematic and layout review
2015-03-23 Started Redesign.
2015-03-25 Done some more layout.
    Need to sort pin swaps for the OE lines and complete routing
2015-04-03 Split design into two modules
2015-04-05 Added some debug headers for power and UART
    Added silkscreen info also.
2015-04-05 Sorted silkscreen out and panelized design.
2015-05-10 Added startings of AVR Code base
2015-05-10 Added C temp files to ignore
2015-05-12 sTUFF
2015-05-31 Lots of code. Still need to get RTC working.
